# Keil uVision project EC1208.uvproj, settings and files
target iTool (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EC1208 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,NDEBUG, MODBUS_RTU,RTC_LSE
  c include: .\GPRS;.\SPIFLASH;.\FRAM;.\User_Code;.\CMSIS\CM3\CoreSupport;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\STM32F10x_StdPeriph_Driver\src;.\STM32F10x_StdPeriph_Driver\inc;.\RTX;.\modbus;.\modbus\rtu;.\modbus\rtu_port;.\modbus\include;.\modbus\functions;.\modbus\tcp;.\RTC;.\WDG;C:\Keil\ARM\ARMCC\include;.\LCD;.\SPI_FLASH;.\ZLG_GUI;.\MEMS;.\DS18B20;.\FATFS;.\SD_Driver;.\FATFS\option;.\spi_sd
  asm include: .\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User_Code
    ./User_Code/: main.c stm32f10x_it.c user_nvic.c user_queue.c user_uart.c user_can.c common.c user_timedelay.c user_timer.c user_adc.c user_gpio.c user_bsp.c user_clock.c user_dac.c user_register.c sys.h test.c
    ./SPIFLASH/: user_spi.c spi_fram.c
  group SPI_FLASH
    ./SPI_FLASH/: MX25_CMD.c spi_flash.c
  group FRAM
    ./FRAM/: FM25CL64.c spi_fram.c
  group RTC
    ./RTC/: user_rt8025x.c rtc.c user_i2c.c
  group modbus
    ./modbus/include/: mbconfig.h
    ./modbus/: mb.c
    ./modbus/rtu/: mbrtu.c mbcrc.c
    ./modbus/functions/: mbfuncholding.c mbutils.c
    ./modbus/tcp/: mbtcp.c
  group rtu_port
    ./modbus/rtu_port/: port.c portevent.c portserial.c porttimer.c
  group RTX
    ./RTX/: RTX_Conf_CM.c
  group STM32F10x_StdPeriph_Driver
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/CM3/CoreSupport/: core_cm3.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group About
    ./About/: About.txt AT Command.txt ublox_NEMA_Message.txt ublox_NMEA_Protocol.txt IO.txt modbus.txt Version.txt 控制器线束定义.txt About CAN  Config.txt
  group WDG
    ./User_Code/: user_wdg.c user_swdg.c
  group LCD
    ./LCD/: Lcd.c config.h LCDDRIVE.H lcddrive.c G-086-PC.C G_086_PC.H
  group ZLG_GUI
    ./ZLG_GUI/: ConvertColor.c font5_7.c FONT8_8.C FONT24_32.C GUI_BASIC.C GUI_StockC.C loadbit.c menu.c spline.c windows.c FONT16_16.c
  group MEMS
    ./MEMS/: LSM330DLC.c
  group DS18B20
    ./DS18B20/: ds18b20.c
  group SD
    ./SD_Driver/: file.c malloc.c sd.c spi.c
  group FATFS
    ./FATFS/: diskio.c exfuns.c ff.c
